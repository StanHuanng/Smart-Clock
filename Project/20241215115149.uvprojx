# Keil uVision project 20241215115149.uvprojx, settings and files
target <20241215115149> (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SC32F10TS8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 20241215115149 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f10xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: menu.h menu.c IR.c Motor.c LED.c Buzzer.c RGB.c Key.c CLOCK.c OLED.c main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_pwm.c sc32f1xxx_tim.c sc32f1xxx_twi.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f10xx.s
